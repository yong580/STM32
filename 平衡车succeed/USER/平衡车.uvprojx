# Keil uVision project 平衡车.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 平衡车 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CORE;..\USER;..\LIB\inc;..\WORKING\WORK_inc;..\MPU_DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_exti.c
  group WORK_src
    ../WORKING/WORK_src/: usart.c sys.c delay.c MPU6050.c MPUIIC.c InputCapture.c PID.c exti.c MyTime.c
  group MPU_DMP
    ../MPU_DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
